# Enable building both u-boot and edk2-firmware
PROVIDES:remove = "virtual/bootloader"
